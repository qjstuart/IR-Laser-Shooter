# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: BasicUI
  c flags: Optim=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group drivers
    ./drivers/: gpio.c timer.c gpio.h platform.h timer.h eeprom.c eeprom.h rtc.c rtc.h lcd.c lcd.h leds.c leds.h delay.c delay.h
  group src
    ./src/: main.c switches.c switches.h shiftregister.h shiftregister.c game_modes.c game_modes.h menu.c menu.h ir.c ir.h piezo.c piezo.h util.c util.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
